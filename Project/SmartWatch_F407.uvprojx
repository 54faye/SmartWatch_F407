# Keil uVision project SmartWatch_F407.uvprojx, settings and files
target SmartWatch_F407 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08010000,0x00030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartWatch_F407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\User;..\Drivers\CMSIS;..\Drivers\Startup;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\BSP;..\App\Config;..\App\Model;..\App\Tasks;..\App\UI;..\App\UI\Pages;..\FreeRTOS\inc;..\FreeRTOS\port;..\Middlewares\Algorithm;..\Middlewares\Utils
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/: main.c stm32f4xx_it.c stm32f4xx_conf.h scheduler.c
  group BSP
    ../Drivers/BSP/: bsp_led.c bsp_key.c bsp_usart.c bsp_i2c.c bsp_oled.c OLED_Data.c bsp_mpu6050.c bsp_adc.c bsp_rtc.c bsp_timer.c bsp_delay.c bsp_spi1.c bsp_w25q128.c bsp_i2c_hw.c bsp_at24c02.c bsp_usart3.c esp8266.c ota_manager.c
  group STARTUP
    ../Drivers/Startup/: startup_stm32f40xx.s
  group CMSIS
    ../Drivers/CMSIS/: stm32f4xx.h system_stm32f4xx.h system_stm32f4xx.c core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group StdPeriph
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_crc.c
  group FREERTOS
    ../FreeRTOS/src/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../FreeRTOS/port/: port.c heap_4.c
  group APP
    ../App/Model/: DataCenter.c SetTime.c
    ../App/Tasks/: task_manager.c test_ota.c task_display.c task_input.c task_sensor.c
    ../App/UI/: UI_Manager.c menu.c dino.c
    ../App/UI/Pages/: Page_Clock.c Page_Menu.c Page_Apps.c
  group MIDDLEWARES
    ../Middlewares/Algorithm/: kalman.c pedometer.c step_algo.c fall_detect.c nn_inference.c
    ../Middlewares/Utils/: debug_serial.c
